options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    packet_len_key: length
    payload_mod: '"BPSK"'
    rolloff: '0'
  states: {}
- name: tutorial_my_qpsk_demod_cb_0
  id: tutorial_my_qpsk_demod_cb
  parameters:
    gray_code: 'True'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [digital_ofdm_tx_0, '0', tutorial_my_qpsk_demod_cb_0, '0']
- [tutorial_my_qpsk_demod_cb_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_ofdm_tx_0, '0']

metadata:
  file_format: 1
